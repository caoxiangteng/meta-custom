FILESEXTRAPATHS_prepend := "${THISDIR}/features:"
SRC_URI_append = " \
file://0001-cxt-add-for-kernel-update.patch\
"
